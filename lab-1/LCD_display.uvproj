# Keil uVision project LCD_display.uvproj, settings and files
target Lab01 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LCD_display
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: PLL.c ST7735.c startup.s UART.h UART.c ADCSWTrigger.c OS.c ADCSWTrigger.h OS.h Timer2.h ADC.h ADC.c Lab01.c
    ../UARTInts_4C123/: PLL.h
