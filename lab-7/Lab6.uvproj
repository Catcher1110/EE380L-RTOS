# Keil uVision project Lab6.uvproj, settings and files
target Lab6 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: PeriodMeasure
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c os.c osasm.s os.h UART2.h UART2.c Lab6.c can.c can0.c can.h can0.h debug.h hw_can.h hw_ints.h hw_memmap.h hw_nvic.h interrupt.h interrupt.c PWM.c
